# Keil uVision project BLE_SimpleMultipleConnections.uvprojx, settings and files
target MasterSlave (5060422::V5.06 update 4 (build 422)::ARMCC)
  device: BlueNRG-355 STMicroelectronics
  pack: Keil.STBlueNRG-LP_DFP.2.0.0
  cpu: IRAM(0x20000000,0x10000) IROM(0x10040000,0x40000) CPUTYPE("Cortex-M0+") CLOCK(12000000) ELITTLE
  output: BLE_SimpleMultipleConnections_MasterSlave +hex
  AfterMake: fromelf.exe --bin MasterSlave\Objects\BLE_SimpleMultipleConnections_MasterSlave.axf --output MasterSlave\Objects\BLE_SimpleMultipleConnections_MasterSlave.bin
  c flags: Optim=3 OneElfS=1 uC99=1 wLevel=2
  c define: CONFIG_NUM_MAX_LINKS=50 USE_FULL_LL_DRIVER STEVAL_IDB011V1 CONFIG_DEVICE_BLUENRG_LP CONFIG_HW_SMPS_10uH CONFIG_HW_HSE_TUNE=32 USER_BUTTON=BSP_PUSH1 CONFIG_HW_LS_XTAL BLE_STACK_FULL_CONF PROFILE_ROLE=ROLE_COLLECTOR MAX_NUM_MASTERS=0 MAX_NUM_SLAVES=50
  c include: ..\..\Inc;..\..\..\..\..\Drivers\Peripherals_Drivers\Inc;..\..\..\..\..\Drivers\CMSIS\Device\ST\BlueNRG_LP\Include;..\..\..\..\..\Middlewares\ST\hal\Inc;..\..\..\..\..\Middlewares\ST\NVMDB\Inc;..\..\..\..\..\Drivers\CMSIS\Include;../../../../../Drivers/BSP/STEVAL-IDB011V1/Inc;..\..\..\..\..\Drivers\BSP\Common\Inc;..\..\..\..\..\Drivers\BSP\Components\lps22hh_STdC\driver;..\..\..\..\..\Drivers\BSP\Components\lsm6dsox_STdC\driver;..\..\..\..\..\Middlewares\ST\BLE_Application\layers_inc;..\..\..\..\..\Middlewares\ST\BLE_Application\OTA\inc;..\..\..\..\..\Middlewares\ST\Bluetooth_LE\Inc;..\..\..\..\..\Middlewares\ST\NVMDB\Inc;..\..\..\..\..\Middlewares\ST\BLE_Application\Profiles\Inc
  asm misc: --cpreproc
  memory RVCT4: ROM 0x10040000 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0x10000
  scatter file: BlueNRG_LP.sct
  group Drivers/BSP
    ../../../../../Drivers/BSP/STEVAL-IDB011V1/Src/: bluenrg_lp_evb_button.c bluenrg_lp_evb_com.c bluenrg_lp_evb_i2c.c bluenrg_lp_evb_io.c bluenrg_lp_evb_led.c bluenrg_lp_evb_mic.c bluenrg_lp_evb_spi.c
    ../../../../../Drivers/BSP/Components/lps22hh_STdC/driver/: lps22hh_reg.c
    ../../../../../Drivers/BSP/Components/lsm6dsox_STdC/driver/: lsm6dsox_reg.c
  group Drivers/CMSIS
    ../../../../../Drivers/CMSIS/Device/ST/BlueNRG_LP/Source/: system_BlueNRG_LP.c
  group Drivers/Peripherals_Drivers
    ../../../../../Drivers/Peripherals_Drivers/Src/: bluenrg_lp_hal_power_manager.c bluenrg_lp_hal_vtimer.c bluenrg_lp_ll_adc.c bluenrg_lp_ll_crc.c bluenrg_lp_ll_dma.c bluenrg_lp_ll_exti.c bluenrg_lp_ll_flash.c bluenrg_lp_ll_gpio.c bluenrg_lp_ll_i2c.c bluenrg_lp_ll_lpuart.c bluenrg_lp_ll_pka.c bluenrg_lp_ll_pwr.c bluenrg_lp_ll_radio.c bluenrg_lp_ll_rcc.c bluenrg_lp_ll_rng.c bluenrg_lp_ll_rtc.c bluenrg_lp_ll_spi.c bluenrg_lp_ll_tim.c bluenrg_lp_ll_timer.c bluenrg_lp_ll_usart.c bluenrg_lp_ll_utils.c
  group Example/User
    ../../Src/: BLE_SimpleMultipleConnections_main.c bluenrg_lp_it.c gatt_db.c procedures.c profile_client_server.c
  group Middlewares/BLE_Stack
    ../../../../../Middlewares/ST/Bluetooth_LE/Library/: libbluenrg_lp_stack.a
    ../../../../../Middlewares/ST/Bluetooth_LE/Src/: stack_user_cfg.c
  group Middlewares/Cryptolib
    ../../../../../Middlewares/ST/cryptolib/: libcrypto.a
  group Middlewares/Hal
    ../../../../../Middlewares/ST/hal/Src/: blue_unit_conversion.s clock.c context_switch.s fifo.c gp_timer.c hal_miscutil.c miscutil.c osal.c
  group Middlewares/NVM
    ../../../../../Middlewares/ST/NVMDB/Src/: nvm_db.c nvm_db_conf.c nvm_db_upper_layer.c
  group Middlewares/OTA
    ../../../../../Middlewares/ST/BLE_Application/OTA/Src/: OTA_btl.c
  group Middlewares/Profiles
    ../../../../../Middlewares/ST/BLE_Application/Profiles/Src/: gap_profile.c gatt_profile.c
target Slave (5060422::V5.06 update 4 (build 422)::ARMCC)
  device: BlueNRG-355 STMicroelectronics
  pack: Keil.STBlueNRG-LP_DFP.2.0.0
  cpu: as above
  output: BLE_SimpleMultipleConnections_Slave +hex
  AfterMake: fromelf.exe --bin Slave\Objects\BLE_SimpleMultipleConnections_Slave.axf --output Slave\Objects\BLE_SimpleMultipleConnections_Slave.bin
  c flags: Optim=3 OneElfS=1 uC99=1 wLevel=2
  c define: CONFIG_NUM_MAX_LINKS=50 USE_FULL_LL_DRIVER STEVAL_IDB011V1 CONFIG_DEVICE_BLUENRG_LP CONFIG_HW_SMPS_10uH CONFIG_HW_HSE_TUNE=32 USER_BUTTON=BSP_PUSH1 CONFIG_HW_LS_XTAL BLE_STACK_FULL_CONF PROFILE_ROLE=ROLE_NODE MAX_NUM_SLAVES=0 MAX_NUM_MASTERS=50
  c include: ..\..\Inc;..\..\..\..\..\Drivers\Peripherals_Drivers\Inc;..\..\..\..\..\Drivers\CMSIS\Device\ST\BlueNRG_LP\Include;..\..\..\..\..\Middlewares\ST\hal\Inc;..\..\..\..\..\Drivers\CMSIS\Include;../../../../../Drivers/BSP/STEVAL-IDB011V1/Inc;..\..\..\..\..\Drivers\BSP\Common\Inc;..\..\..\..\..\Drivers\BSP\Components\lps22hh_STdC\driver;..\..\..\..\..\Drivers\BSP\Components\lsm6dsox_STdC\driver;..\..\..\..\..\Middlewares\ST\BLE_Application\layers_inc;..\..\..\..\..\Middlewares\ST\BLE_Application\OTA\inc;..\..\..\..\..\Middlewares\ST\Bluetooth_LE\Inc;..\..\..\..\..\Middlewares\ST\NVMDB\Inc;..\..\..\..\..\Middlewares\ST\BLE_Application\Profiles\Inc
  asm misc: --cpreproc
  memory RVCT4: ROM 0x10040000 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0x10000
  scatter file: BlueNRG_LP.sct
target Master (5060422::V5.06 update 4 (build 422)::ARMCC)
  device: BlueNRG-355 STMicroelectronics
  pack: Keil.STBlueNRG-LP_DFP.2.0.0
  cpu: as above
  output: BLE_SimpleMultipleConnections_Master +hex
  AfterMake: fromelf.exe --bin Master\Objects\BLE_SimpleMultipleConnections_Master.axf --output Master\Objects\BLE_SimpleMultipleConnections_Master.bin
  c flags: Optim=3 OneElfS=1 uC99=1 wLevel=2
  c define: USE_FULL_LL_DRIVER STEVAL_IDB011V1 CONFIG_DEVICE_BLUENRG_LP CONFIG_HW_SMPS_10uH CONFIG_HW_HSE_TUNE=32 USER_BUTTON=BSP_PUSH1 CONFIG_HW_LS_XTAL BLE_STACK_FULL_CONF PROFILE_ROLE=ROLE_INQUIRER MAX_NUM_MASTERS=0 MAX_NUM_SLAVES=1
  c include: as above
  asm misc: --cpreproc
  memory RVCT4: ROM 0x10040000 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0x10000
  scatter file: BlueNRG_LP.sct
software components: CMSIS:CORE 5.1.1
